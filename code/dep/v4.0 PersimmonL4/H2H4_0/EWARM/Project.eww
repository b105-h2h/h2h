<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H2H4_0.ewp</path>
  </project>
  <batchBuild />
</workspace>
